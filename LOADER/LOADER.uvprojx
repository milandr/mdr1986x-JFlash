# Keil uVision project LOADER.uvprojx, settings and files
target MDR32F9Qx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: LOADER
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_MDR1986VE9x
  c include: .\source\CMSIS\CM3\CoreSupport;.\source\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\source\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup;.\source\MDR32F9Qx_StdPeriph_Driver\inc;.\source\Config;.\source\RTT
  asm define: USE_MDR1986VE9x
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x6000
  group Source
    ./source/: LOADER.c
    ./source/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s
    ./source/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/: system_MDR32F9Qx.c
    ./source/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
